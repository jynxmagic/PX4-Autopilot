## src/examples/ai_controller/Kconfig
```kconfig
menuconfig EXAMPLES_AI_CONTROLLER
	bool "ai_controller"
	default n
	---help---
		Enable support for ai control
```
